# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc5410x (ARM-ADS)
  device: LPC54102:M4 NXP
  pack: Keil.LPC54000_DFP.1.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-lpc5410x +hex
  c flags: Optim=1 wLevel=2
  c define: CORE_M4
  c include: .;..\..\components\drivers\include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;Libraries\CMSIS\Include;Libraries\lpc_chip\chip_5410x;Libraries\lpc_chip\chip_5410x\config;Libraries\lpc_chip\chip_common;applications;drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c board.c demo_thread.c startup.c
  group Drivers
    drivers/: drv_led.c drv_uart.c
    ./drivers/: drv_i2c_soft.c mpu6050.c
  group CMSIS
    Libraries/Device/startup/: sysinit.c keil_startup_lpc5410x.s
  group Libraries
    Libraries/lpc_chip/chip_5410x/power_lib/keil/: lib_power.lib
    Libraries/lpc_chip/chip_common/: fpu_init.c iap.c ring_buffer.c rtc_ut.c
    Libraries/lpc_chip/chip_5410x/: chip_5410x.c clock_5410x.c crc_5410x.c fifo_5410x.c gpiogroup_5410x.c gpio_5410x.c hw_adc.c hw_dmaaltd.c hw_dmaaltd_rom_api.c hw_i2cmd.c hw_i2cmd_rom_api.c hw_i2cmond.c hw_i2cmond_rom_api.c hw_i2csd.c hw_i2csd_rom_api.c hw_spimd.c hw_spimd_rom_api.c hw_spisd.c hw_spisd_rom_api.c hw_uart.c iocon_5410x.c pinint_5410x.c pll_5410x.c ritimer_5410x.c romapi_adc.c romapi_dma.c romapi_i2cm.c romapi_i2cmon.c romapi_i2cs.c romapi_spim.c romapi_spis.c romapi_uart.c rtc_5410x.c sct_5410x.c sct_pwm_5410x.c stopwatch_5410x.c syscon_5410x.c sysinit_5410x.c timer_5410x.c utick_5410x.c wwdt_5410x.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
